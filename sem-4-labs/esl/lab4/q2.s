	AREA RESET, DATA, READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=NUM
	LDR R6,=RESULT
	MOV R2,#0
	MOV R5,#0
	LDR R4,[R0]
	
UP	CMP R4,#100
	BLO L1
	SUBS R4,#100
	ADD R2, R2,#1
	BNE UP
	
L1	CMP R4,#10
	BLO L2
	SUBS R4,#10
	ADD R5, R5,#1
	BNE L1
	
L2	LSL R5, R5,#4
	ORR R8, R4, R5
	LSL R9, R2, #8
	ORR R9, R8, R9
	STR R9, [R6]
	
STOP
	B STOP
NUM DCD 0x35
	AREA mydata, DATA, READWRITE
RESULT DCD 0,0,0,0,0,0,0,0,0,0
	END