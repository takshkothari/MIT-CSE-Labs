		AREA RESET,DATA,READONLY
		EXPORT __Vectors
__Vectors
		DCD 0x10001000
		DCD Reset_Handler
		ALIGN
		AREA mycode,CODE,READONLY
		ENTRY
		EXPORT Reset_Handler
Reset_Handler
		LDR R0, =N1
		LDR R1, =N2
		LDR R2,[R0]
		LDR R3,[R1]
		LDR R4, =GCD
		LDR R5, =LCM
BACK 	CMP R2,R3
		BEQ EXIT
		BCC DOWN
		SUB R2,R3
		B BACK
EXIT 	STRB R3,[R4]
		B L
DOWN 	SUBS R3,R2
		B BACK
L		LDR R2,[R0]
		LDR R6,[R1]
		MOV R8,#0
		MUL R7,R2,R6
UP		CMP R7,R2
		BCC STORE
		SUBS R7,R7,R2
		ADD R8,#1
		B UP
STORE 	STR R8,[R5]
STOP 	B STOP
N1 DCD 	0x12
N2 DCD 	0x36 	
		AREA mydata,DATA,READWRITE
GCD DCD 0
LCM DCD 0 
		END